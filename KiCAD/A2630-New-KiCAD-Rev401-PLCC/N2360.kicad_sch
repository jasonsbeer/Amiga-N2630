File: KiCAD/A2630-New-KiCAD-Rev401-PLCC/N2360.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Revision 4.1.0
Other:
- title: Amiga N2630 -> Amiga N2630 MC68882 PLCC
